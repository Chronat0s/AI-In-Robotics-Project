Commit message: changed goal, rewards, and obs

File: cobot-env/cobot_ai4robotics/resources/simplegoal.urdf (robot description, URDF)
Before this commit: robot simplegoal, 1 links, 0 joints
Links:
- link base_link: geometry visual cylinder length=0.05 radius=0.05
